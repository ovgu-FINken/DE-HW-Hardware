# Repository ovgu-FINken/DE-HW-Hardware

## KiCad design extensionBoard.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C7, C8, C9, C10, C12, C13, C14: 100n; C_0603_HandSoldering
C6, C11: 4.7u; SMD-1206_Pol
C15, C16: 1u; C_1206_HandSoldering
D1: Power; LED_0805
D2: PC0; LED_0805
D3: 5V; LED_0805
D4: PC1; LED_0805
D5: RGB1; LED_WS2812B
D6: RGB2; LED_WS2812B
D7: RGB3; LED_WS2812B
D8: RGB4; LED_WS2812B
J1: 5V; Pin_Header_Angled_1x02_Pitch2.54mm
P1: I2C1; Socket_Strip_Angled_1x04_Pitch2.54mm
P2: FI2C1; Socket_Strip_Angled_1x04_Pitch2.54mm
P3: UART4; Socket_Strip_Angled_1x04_Pitch2.54mm
P4: ADC1; Socket_Strip_Angled_1x03_Pitch2.54mm
P5: ADC2; Socket_Strip_Angled_1x03_Pitch2.54mm
P6: RGB_OUT; Socket_Strip_Angled_1x03_Pitch2.54mm
P7: Power; Molex_PicoBlade_53261-0371_03x1.25mm_Angled
P8: UART1; Pin_Header_Straight_1x04_Pitch2.54mm
P9: JTAG-10; FTSH-105-XX-X-DV
P10: SPI1; Socket_Strip_Angled_1x06_Pitch2.54mm
R1, R2, R11, R12: 10k; R_0603_HandSoldering
R3, R4, R5, R6: 2k; R_0603_HandSoldering
R7, R8, R9, R10: 150; R_0603_HandSoldering
R13, R14: 10k; C_0603_HandSoldering
SW1: Reset; SW_SPST_B3S-1000
SW2: USER; SW_SPST_B3S-1000
U1: STM32F446RETx; LQFP-64_10x10mm_Pitch0.5mm
U2: MCP1700T-3002E/TT; SOT-23_Handsoldering

Connections:
/3.3V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C14.2, C16.1, D1.2, P3.2, P4.2, P5.2, P7.2, P8.2, P9.1 (VCC), P10.2, R1.2, R11.2, R12.2, R13.1, U1.1 (VBAT), U1.13 (VDDA), U1.19 (VDD), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD), U2.2
/5V: C7.2, C8.2, C9.2, C10.2, C15.1, D3.2, D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), J1.2, P1.2, P2.2, P6.2, P7.3, R3.2, R4.2, R5.2, R6.2, U2.3
/ADC1_IN0: P4.3, U1.14 (ADC1_IN0/ADC2_IN0/ADC3_IN0/RTC_AF2/SYS_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)
/ADC2_IN1: P5.3, U1.15 (ADC1_IN1/ADC2_IN1/ADC3_IN1/QUADSPI_BK1_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)
/BOOT0: R1.1, R2.2, U1.60 (BOOT0)
/BOOT1: R13.2, R14.2, U1.28 (BOOT1/I2S3_SD/QUADSPI_CLK/SAI1_SD_A/SDI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)
/FI2C1_SCL: P2.3, R5.1, U1.37 (PC6/DCMI_D0/FMPI2C1_SCL/I2S2_MCK/SDIO_D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)
/FI2C1_SDA: P2.4, R6.1, U1.38 (PC7/DCMI_D1/FMPI2C1_SDA/I2S2_CK/I2S3_MC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)
/GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.2, C7.1, C8.1, C9.1, C10.1, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), J1.1, P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, P9.3 (GND), P9.5 (GND), P9.9 (GND), P10.1, R2.1, R7.2, R8.2, R9.2, R10.2, R14.1, SW1.2, SW2.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS), U2.1
/I2C1_SCL: P1.3, R3.1, U1.58 (CAN2_TX/CEC/DCMI_D5/I2C1_SCL/QUADSPI_BK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)
/I2C1_SDA: P1.4, R4.1, U1.59 (DCMI_VSYNC/I2C1_SDA/SPDIFRX_IN0/TIM4_CH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)
/NRST: C12.1, P9.10 (tRST), R11.1, SW1.1, U1.7 (NRST)
/PC0: D2.2, U1.8 (PC0/ADC1_IN10/ADC2_IN10/ADC3_IN10/SAI1_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)
/PC1: D4.2, U1.9 (PC1/ADC1_IN11/ADC2_IN11/ADC3_IN11/I2S2_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)
/PC2: C13.1, R12.1, SW2.1, U1.10 (PC2/ADC1_IN12/ADC2_IN12/ADC3_IN12/SPI2_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)
/PC5: D5.4 (DIN), U1.25 (PC5/ADC1_IN15/ADC2_IN15/SPDIFRX_IN3/USA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)
/RGB_OUT: D8.2 (DOUT), P6.3
/SPI1_MISO: P10.5, U1.22 (ADC1_IN6/ADC2_IN6/DCMI_PIXCLK/I2S2_MCK/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)
/SPI1_MOSI: P10.6, U1.23 (ADC1_IN7/ADC2_IN7/I2S1_SD/SPI1_MOSI/TIM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)
/SPI1_NSS: P10.3, U1.20 (ADC1_IN4/ADC2_IN4/DAC_OUT1/DCMI_HSYNC/I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)
/SPI1_SCK: P10.4, U1.21 (ADC1_IN5/ADC2_IN5/DAC_OUT2/I2S1_CK/SPI1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)
/SPI2_MISO: U1.35 (SPI2_MISO/TIM12_CH1/TIM1_CH2N/TIM8_CH2N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)
/SPI2_MOSI: U1.36 (ADC1_EXTI15/ADC2_EXTI15/ADC3_EXTI15/I2S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)
/SPI2_NSS: U1.33 (CAN2_RX/I2C2_SMBA/I2S2_WS/SAI1_SCK_B/SP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)
/SPI2_SCK: U1.34 (CAN2_TX/I2S2_CK/SPI2_SCK/TIM1_CH1N/USAR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)
/SWDCLK: P9.4 (TCK), U1.49 (SYS_JTCK-SWCLK/PA14)
/SWDIO: P9.2 (TMS), U1.46 (SYS_JTMS-SWDIO/PA13)
/SWDO: P9.6 (TDO), U1.55 (I2C2_SDA/I2S1_CK/I2S3_CK/SPI1_SCK/SPI3_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)
/UART4_RX: P3.3, U1.52 (PC11/ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI1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)
/UART4_TX: P3.4, U1.51 (PC10/DCMI_D8/I2S3_CK/QUADSPI_BK1_IO1/SD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)
/USART1_RX: P8.3, U1.43 (DCMI_D1/TIM1_CH3/USART1_RX/USB_OTG_FS_I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)
/USART1_TX: P8.4, U1.42 (DAC_EXTI9/DCMI_D0/I2C3_SMBA/I2S2_CK/SAI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)
unnamed: C11.1, U1.30 (VCAP_1)
unnamed: D1.1, R7.1
unnamed: D2.1, R8.1
unnamed: D3.1, R9.1
unnamed: D4.1, R10.1
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)

Notes on the sheet:
Decoupling Caps
JTAG
I2C1
FI2C1
UART4
ADC1
ADC2
Power 3.3V & 5V
LED Power
LED PC0
LED 5V
LED PC1
Decoupling WS2812
RGB_OUT
Reset Button
USER Button
UART1
SPI1
Voltage Regulator

Board: 2 copper layers, 45.0 x 60.0 mm, 53 parts (23 on the bottom side), 36 nets.

## KiCad design PCBs/tele.kicad_pcb

Schematic: tele.sch

Parts:
CON1: AVR-JTAG-ICE
IC1: DERFMEGA128-22A02; deRFmega128-22A02
P1: TELE; Socket_Strip_Angled_1x04_Pitch2.54mm

Connections:
/3.3V: CON1.4, IC1.24, P1.2
/NC: CON1.7
/TCK: CON1.1, IC1.38
/TDI: CON1.9, IC1.44
/TDO: CON1.3, IC1.42
/TMS: CON1.5, IC1.40
GND: CON1.2, CON1.10, IC1.2, IC1.22, IC1.23, IC1.25, IC1.45, IC1.46, P1.1
unnamed: CON1.6, CON1.8, IC1.5
unnamed: IC1.26, P1.4
unnamed: IC1.28, P1.3

Board: 2 copper layers, 33.7 x 33.7 mm, 3 parts (1 on the bottom side), 9 nets.

## KiCad design pgbnoroute.kicad_pcb

Schematic: PDB.sch

Parts:
J_REG_3.3V_1, J_REG_5V/1A_1: 5V.R; 5V_VOLTAGE_REGULATOR
P1: BATT; Socket_Strip_Angled_1x02_Pitch2.54mm
P2, P3, P4, P5, P6, P7: CONN_01X04; Socket_Strip_Angled_1x04_Pitch2.54mm

Connections:
/3.3V: J_REG_3.3V_1.VOUT, P2.3, P3.3, P4.3, P5.3, P6.3, P7.3
/5V: J_REG_5V/1A_1.VOUT, P2.4, P3.4, P4.4, P5.4, P6.4, P7.4
/12V: J_REG_3.3V_1.VIN, J_REG_5V/1A_1.VIN, P1.2, P2.2, P3.2, P4.2, P5.2, P6.2, P7.2
GND: J_REG_3.3V_1.GND, J_REG_5V/1A_1.GND, P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1; also elsewhere on the board

Schematic: PGP.sch

Parts:
J_REG_3.3V_1, J_REG_5V/1A_1: 5V.R; 5V_VOLTAGE_REGULATOR
P1: BATT; Socket_Strip_Angled_1x02_Pitch2.54mm
P2, P3, P4, P5, P6, P7: CONN_01X04; Socket_Strip_Angled_1x04_Pitch2.54mm
P8, P9, P10, P11: GND; Pin_Header_Straight_1x01_Pitch2.54mm

Connections:
/3.3V: J_REG_3.3V_1.VOUT, P2.3, P3.3, P4.3, P5.3, P6.3, P7.3
/5V: J_REG_5V/1A_1.VOUT, P2.4, P3.4, P4.4, P5.4, P6.4, P7.4
/12V: J_REG_3.3V_1.VIN, J_REG_5V/1A_1.VIN, P1.2, P2.2, P3.2, P4.2, P5.2, P6.2, P7.2
GND: J_REG_3.3V_1.GND, J_REG_5V/1A_1.GND, P1.1, P2.1, P3.1, P4.1, P5.1, P6.1, P7.1, P8.1, P9.1, P10.1, P11.1

Board: 2 copper layers, 30.7 x 49.8 mm, 13 parts (1 on the bottom side), 4 nets.

## KiCad design PCBs/DE-HW FINAL.kicad_pcb

Schematic: vdfv.sch

Parts:
C1: 4.7uF; C_0805_HandSoldering
C2, C3, C8, C9, C10, C11, C12, C13, C14: 0.1U; C_0805_HandSoldering
C4, C5, C15: 100nF; C_0805_HandSoldering
C6: 1U; SMD-1206_Pol
C7: 4.7U; SMD-1206_Pol
D2, D3, D4, D5: LED; LED_0805
D6, D7, D8, D9: WS2812B; LED_WS2812B-PLCC4
JP1: OPTICAL-FLOW; Socket_Strip_Straight_1x04
JP2: AUTOPILOT; Socket_Strip_Angled_1x04
JP3: ILLUMINSENSORI2C2; Socket_Strip_Straight_1x04
JP4: JTAG; Pin_Header_Straight_2x05_Pitch1.27mm
JP7: IR DISTANCE; Socket_Strip_Angled_1x04
JP8: CURENT SENSOR; Socket_Strip_Straight_1x03
JP9: RANGING SENSOR; Socket_Strip_Straight_1x04
P1: CONN WS2812; Socket_Strip_Angled_1x03
P4, P5, P6, P7: I2C-SONAR; Socket_Strip_Straight_1x04
P11: voltage conn; Socket_Strip_Straight_1x03
P12: voltage connector; Socket_Strip_Straight_1x03
R1, R2, R9, R10, R11, R12, R13, R14: 4.7KE; R_0805_HandSoldering
R3, R7: 10KE; R_0805_HandSoldering
R4, R5, R6, R8: 470E; R_0805_HandSoldering
SW1, SW2: SW_PUSH; SW_SPST_PTS645
U1: STM32F446RETx; LQFP-64_10x10mm_Pitch0.5mm

Connections:
/3.3V: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, JP3.2, JP4.4, P11.2, R1.1, R3.1, R7.1, R8.2, R13.1, R14.1, U1.1 (VBAT), U1.13 (VDDA), U1.48 (VDD), U1.64 (VDD)
/5V: C2.1, C3.1, C13.1, C14.1, D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), JP1.3, JP7.2, JP8.2, P1.2, P4.2, P5.2, P6.2, P7.2, P12.1, R9.1, R10.1, R11.1, R12.1
/BOOT0: R1.2, R2.2, U1.60 (BOOT0)
/DIN: D6.4 (DIN), U1.58 (CAN2_TX/CEC/DCMI_D5/I2C1_SCL/QUADSPI_BK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)
/DIN1: D6.2 (DOUT), D7.4 (DIN)
/DIN2: D7.2 (DOUT), D8.4 (DIN)
/DIN3: D8.2 (DOUT), D9.4 (DIN)
/ENABLE: JP7.4, U1.15 (ADC1_IN1/ADC2_IN1/ADC3_IN1/QUADSPI_BK1_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)
/I2C2SCL: JP3.3, R14.2, U1.29 (I2C2_SCL/I2S2_CK/SAI1_SCK_A/SPI2_SCK/TI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)
/I2C2SDA: JP3.4, R13.2, U1.53 (PC12/DCMI_D9/I2C2_SDA/I2S3_SD/SDIO_CK/S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)
/NRST: C4.2, JP4.6, JP4.8, R7.2, SW1.1, U1.7 (NRST)
/OUT: JP7.3, U1.14 (ADC1_IN0/ADC2_IN0/ADC3_IN0/RTC_AF2/SYS_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)
/PC0: C15.2, R3.2, SW2.1, U1.8 (PC0/ADC1_IN10/ADC2_IN10/ADC3_IN10/SAI1_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)
/PC1: R4.2, U1.9 (PC1/ADC1_IN11/ADC2_IN11/ADC3_IN11/I2S2_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)
/PC2: R5.2, U1.10 (PC2/ADC1_IN12/ADC2_IN12/ADC3_IN12/SPI2_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)
/PC3: R6.2, U1.11 (PC3/ADC1_IN13/ADC2_IN13/ADC3_IN13/I2S2_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)
/PC10: JP2.4, U1.51 (PC10/DCMI_D8/I2S3_CK/QUADSPI_BK1_IO1/SD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)
/PC11: JP2.3, U1.52 (PC11/ADC1_EXTI11/ADC2_EXTI11/ADC3_EXTI1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)
/SCL: P4.4, P5.4, P6.4, P7.4, R10.2, U1.61 (CAN1_RX/DCMI_D6/I2C1_SCL/SDIO_D4/TIM10_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)
/SDA: P4.3, P5.3, P6.3, P7.3, R9.2, U1.59 (DCMI_VSYNC/I2C1_SDA/SPDIFRX_IN0/TIM4_CH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)
/SDI: JP4.9, U1.50 (ADC1_EXTI15/ADC2_EXTI15/ADC3_EXTI15/CEC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)
/SWCLK: JP4.1, U1.49 (SYS_JTCK-SWCLK/PA14)
/SWDIO: JP4.5, U1.46 (SYS_JTMS-SWDIO/PA13)
/SWO: JP4.3, U1.55 (I2C2_SDA/I2S1_CK/I2S3_CK/SPI1_SCK/SPI3_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)
GND: C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, D2.1, D3.1, D4.1, D5.1, D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), JP1.4, JP2.1, JP3.1, JP4.2, JP4.10, JP7.1, JP8.1, P1.1, P4.1, P5.1, P6.1, P7.1, P11.3, P12.2, R2.1, SW1.2, SW2.2, U1.12 (VSSA), U1.18 (VSS), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS)
unnamed: C1.1, U1.30 (VCAP_1)
unnamed: D2.2, R4.1
unnamed: D3.2, R5.1
unnamed: D4.2, R6.1
unnamed: D5.2, R8.1
unnamed: D9.2 (DOUT), P1.3
unnamed: JP1.1, R12.2, U1.38 (PC7/DCMI_D1/FMPI2C1_SDA/I2S2_CK/I2S3_MC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)
unnamed: JP1.2, R11.2, U1.37 (PC6/DCMI_D0/FMPI2C1_SCL/I2S2_MCK/SDIO_D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)
unnamed: JP8.3, U1.16 (ADC1_IN2/ADC2_IN2/ADC3_IN2/TIM2_CH3/TIM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)
unnamed: JP9.1, U1.20 (ADC1_IN4/ADC2_IN4/DAC_OUT1/DCMI_HSYNC/I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)
unnamed: JP9.2, U1.21 (ADC1_IN5/ADC2_IN5/DAC_OUT2/I2S1_CK/SPI1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)
unnamed: JP9.3, U1.22 (ADC1_IN6/ADC2_IN6/DCMI_PIXCLK/I2S2_MCK/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)
unnamed: JP9.4, U1.23 (ADC1_IN7/ADC2_IN7/I2S1_SD/SPI1_MOSI/TIM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)
unnamed: U1.19 (VDD), U1.32 (VDD)

Board: 2 copper layers, 80.0 x 80.0 mm, 54 parts (20 on the bottom side), 39 nets.

## Commit log

2016-11-16 adding README
2016-11-23 Created testfile
    This will be removed later
2017-01-11 Add telemetry model eagle file
2017-01-25 adding outline
2017-03-15 power distribution board
2017-03-17 power distribution updated
2017-03-29 updated power distribution design
2017-03-31 updated power distribution board and 3D view of board
2017-04-05 ADDED GND PINS AND VIAS IN POWERDISTRIBUTION BOARD
2017-04-12 power distribution board modified
2017-04-19 final change
    * remove vias to get better connectivity on GND and 5V
2017-05-02 Add files via upload
    Microcontroller Processing board
2017-05-03 Revert "Delete telem.kicad_pcb"
    This reverts commit 428ede25c780ff7cc4c2e1b1b8b084abe53af5dc.
2017-07-06 Create Images
2017-07-06 Images
2017-07-07 Create FinkinHW
2017-07-07 pcb schema
2017-07-07 Kicad pcb
2017-07-07 pcb.net
2017-07-07 telemetry board
2017-07-12 Finken Robot
2017-07-19 Revert "Delete pgbnoroute.kicad_pcb"
    This reverts commit 03916411cba97f59808030e2a8b958beb91e0c31.
2017-07-19 Revert "Delete pdb.sch"
    This reverts commit ee8ddf2a4fc33bba99d2671265c5584ef1e4acb3.
2017-07-19 Revert "Delete pdb.pro"
    This reverts commit 1858ef534cab4a3bc5a37715ff5a9407c1a6c613.
2017-07-19 Revert "Delete PGP.sch"
    This reverts commit 747073c0ff628fc374fc47d9e9ca80d4d126c071.
2017-07-19 Revert "Delete PGP.pro"
    This reverts commit 412439fcdd2fa55825f167fb8fa7762efd1a6a79.
2017-07-19 Revert "Delete PGP.net"
    This reverts commit e3c487b0faa24d1a1290a9bd027fba511f6a2441.
2017-07-19 Revert "Delete pgbnoroute.kicad_pcb"
    This reverts commit d04231a91b9aebc76e86eb83c28878ba672e5e4c.
2017-09-10 ws2812 image
2017-09-13 3d pdb
2017-09-15 3.3pololu image
2017-09-15 5V pololu image
2017-09-15 stm32 assembly instruction
2017-09-18 LED 0805
2017-09-18 0805 LED
2017-10-27 tele position
2017-10-27 tele no gnd
2017-10-29 pdbtop
2017-10-29 pdbbottom
2017-11-02 PDB SILK SCREEN
